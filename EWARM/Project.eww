<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\DSv1.5.ewp</path>
  </project>
  <batchBuild />
</workspace>
